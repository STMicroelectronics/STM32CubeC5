# IAR project appli.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32C5A3ZG ST STM32C5A3ZG
  General.FPU2: 6
  ICCARM.CCDefines: STM32C5A3xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../appli/user_modifiable/_release_IAR_NUCLEO-C5A3ZG/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../stm32c5xx_dfp/Include; ../../../../../../../stm32c5xx_drivers/hal; ../../../../../../../stm32c5xx_drivers/ll; ../../../../../../../stm32c5xx_drivers/timebases; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../appli; ../../appli/generated/hal; ../../appli/generated/utilities/basic_stdio; ../../appli/user_modifiable/_release_IAR_NUCLEO-C5A3ZG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32C5A3xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ../../bin/appli.hex
  prebuild: python "..\..\appli\project_appli.py" prebuild --compiler IAR
  postbuild: python "..\..\appli\project_appli.py" postbuild
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../appli/user_modifiable/Device/STM32C5A3ZGT6/stm32c5a3xg_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group appli
    ../../appli/: appli_flash_layout.h com.c com.h common.c common.h data.c data.h Driver_Common.h Driver_Flash.h fw_update_app.c fw_update_app.h low_level_device.c low_level_flash.c low_level_flash.h main.c main.h ymodem.c ymodem.h
  group appli/generated/hal
    ../../appli/generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_crc.c mx_crc.h mx_def.h mx_flash.c mx_flash.h mx_hal_def.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_usart2.c mx_usart2.h stm32_external_env.h stm32c5xx_hal_conf.h
  group appli/generated/utilities/basic_stdio
    ../../appli/generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group appli/user_modifiable/Device/STM32C5A3ZGT6
    ../../appli/user_modifiable/Device/STM32C5A3ZGT6/: startup_stm32c5a3xx.c system_stm32c5xx.c
  group stm32c5xx_dfp
    ../../../../../../../stm32c5xx_dfp/: README.md
  group stm32c5xx_dfp/Include
    ../../../../../../../stm32c5xx_dfp/Include/: stm32c5xx.h
  group stm32c5xx_drivers
    ../../../../../../../stm32c5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32c5xx_drivers/doc
    ../../../../../../../stm32c5xx_drivers/doc/: STMicroelectronics.stm32c5xx_hal_drivers_dependencies.md
  group stm32c5xx_drivers/hal
    ../../../../../../../stm32c5xx_drivers/hal/: stm32_hal.h stm32c5xx_hal_cortex.c stm32c5xx_hal_cortex.h stm32c5xx_hal_crc.c stm32c5xx_hal_crc.h stm32c5xx_hal_def.h stm32c5xx_hal_dma.c stm32c5xx_hal_dma.h stm32c5xx_hal_flash_itf.c stm32c5xx_hal_flash_itf.h stm32c5xx_hal_flash.c stm32c5xx_hal_flash.h stm32c5xx_hal_gpio.c stm32c5xx_hal_gpio.h stm32c5xx_hal_icache.c stm32c5xx_hal_icache.h stm32c5xx_hal_pwr.c stm32c5xx_hal_pwr.h stm32c5xx_hal_q.c stm32c5xx_hal_q.h stm32c5xx_hal_rcc.c stm32c5xx_hal_rcc.h stm32c5xx_hal_uart.c stm32c5xx_hal_uart.h stm32c5xx_hal.c stm32c5xx_hal.h
  group stm32c5xx_drivers/ll
    ../../../../../../../stm32c5xx_drivers/ll/: stm32c5xx_ll_bus.h stm32c5xx_ll_crc.h stm32c5xx_ll_dma.h stm32c5xx_ll_exti.h stm32c5xx_ll_flash.h stm32c5xx_ll_gpio.h stm32c5xx_ll_icache.h stm32c5xx_ll_pwr.h stm32c5xx_ll_rcc.h stm32c5xx_ll_usart.h stm32c5xx_ll_utils.h
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
