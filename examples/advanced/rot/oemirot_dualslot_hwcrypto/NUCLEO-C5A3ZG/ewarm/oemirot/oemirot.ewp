# IAR project oemirot.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32C5A3ZG ST STM32C5A3ZG
  General.FPU2: 0
  ICCARM.CCDefines: STM32C5A3xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../oemirot/user_modifiable/_release_IAR_NUCLEO-C5A3ZG/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/mbedtls/configs; ../../../../../../../middleware/mbedtls/include; ../../../../../../../middleware/mbedtls/include/mbedtls; ../../../../../../../middleware/mbedtls/include/psa; ../../../../../../../middleware/mbedtls/library; ../../../../../../../middleware/mcuboot/boot/bootutil/include; ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil; ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil/crypto; ../../../../../../../middleware/mcuboot/boot/bootutil/src; ../../../../../../../middleware/mcuboot/platform_common; ../../../../../../../middleware/stfcf/mbedtls_alt/include/common; ../../../../../../../middleware/stfcf/mbedtls_alt/include/hal; ../../../../../../../stm32c5xx_dfp/Include; ../../../../../../../stm32c5xx_drivers/hal; ../../../../../../../stm32c5xx_drivers/ll; ../../../../../../../stm32c5xx_drivers/timebases; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../oemirot; ../../oemirot/generated/hal; ../../oemirot/generated/middleware/stfcf; ../../oemirot/generated/utilities/basic_stdio; ../../oemirot/user_modifiable/_release_IAR_NUCLEO-C5A3ZG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: STM32C5A3xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ../../bin/oemirot.hex
  prebuild: python "../../oemirot/project_oemirot.py" prebuild --compiler IAR
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../oemirot/user_modifiable/Device/STM32C5A3ZGT6/stm32c5a3xg_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group middleware/mbedtls/include/mbedtls
    ../../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cmac.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h gcm.h mbedtls_config.h memory_buffer_alloc.h rsa.h sha256.h version.h
  group middleware/mbedtls/include/psa
    ../../../../../../../middleware/mbedtls/include/psa/: crypto_adjust_config_dependencies.h crypto_platform.h crypto_types.h crypto_values.h crypto.h
  group middleware/mbedtls/library
    ../../../../../../../middleware/mbedtls/library/: aes.c aria.c asn1parse.c asn1write.c base64.c bignum_core.c bignum_core.h bignum_internal.h bignum.c bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c cipher_wrap.c cipher.c cmac.c constant_time_internal.h constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp_curves.c ecp.c entropy_poll.c entropy.c error.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c nist_kw.c oid.c pem.c pk_ecc.c pk_wrap.c pk.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform_util.c platform.c poly1305.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_driver_wrappers_no_static.h psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto.c psa_its_file.c psa_util_internal.h psa_util.c ripemd160.c rsa_alt_helpers.c rsa_alt_helpers.h rsa.c sha1.c sha256.c sha3.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_debug_helpers_generated.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version_features.c version.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509.c x509write_crt.c x509write_csr.c x509write.c
  group middleware/mcuboot
    ../../../../../../../middleware/mcuboot/: LICENSE.md README.md ST_Release_Notes.md SW_Security_Level.md
  group middleware/mcuboot/boot/bootutil/include/bootutil
    ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil/: boot_hooks.h boot_public_hooks.h boot_record.h bootutil_log.h bootutil_public.h bootutil.h caps.h enc_key_public.h enc_key.h fault_injection_hardening_delay_rng.h fault_injection_hardening.h ignore.h image.h mcuboot_status.h ramload.h security_cnt.h sign_key.h
  group middleware/mcuboot/boot/bootutil/include/bootutil/crypto
    ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil/crypto/: aes_ctr.h aes_kw.h common.h ecdh_p256.h ecdh_x25519.h ecdsa.h hmac_sha256.h rsa.h sha.h
  group middleware/mcuboot/boot/bootutil/src
    ../../../../../../../middleware/mcuboot/boot/bootutil/src/: boot_record.c bootutil_misc.c bootutil_misc.h bootutil_priv.h bootutil_public.c caps.c encrypted.c fault_injection_hardening_delay_rng_mbedtls.c fault_injection_hardening.c image_ecdsa.c image_ed25519.c image_validate.c loader.c swap_misc.c swap_move.c swap_priv.h swap_scratch.c tlv.c
  group middleware/mcuboot/docs
    ../../../../../../../middleware/mcuboot/docs/: design.md ecdsa.md encrypted_images.md index.md release-notes.md
  group middleware/mcuboot/platform_common
    ../../../../../../../middleware/mcuboot/platform_common/: boot_hal.h cryptoboot_hal.h Driver_Common.h Driver_Flash.h fih.h flash_map_backend.h flash_map_extended.c flash_map_legacy.c flash_map.c flash_map.h main.c mcuboot_logging.h plat_defs.h plat_nv_counters.h security_cnt.c shared_data.c sysflash.h
  group middleware/stfcf
    ../../../../../../../middleware/stfcf/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group middleware/stfcf/mbedtls_alt/include/common
    ../../../../../../../middleware/stfcf/mbedtls_alt/include/common/: aes_alt.h ccm_alt.h ecp_alt.h entropy_hardware_alt.h gcm_alt.h rsa_alt.h sha1_alt.h sha256_alt.h sha512_alt.h
  group middleware/stfcf/mbedtls_alt/include/hal
    ../../../../../../../middleware/stfcf/mbedtls_alt/include/hal/: hal_aes_alt.h hal_ccm_alt.h hal_ecp_alt.h hal_entropy_hardware_alt.h hal_gcm_alt.h hal_rsa_alt.h hal_sha1_alt.h hal_sha256_alt.h hal_sha512_alt.h
  group middleware/stfcf/mbedtls_alt/source/hal
    ../../../../../../../middleware/stfcf/mbedtls_alt/source/hal/: aes_aes_alt.c aes_ccm_alt.c aes_gcm_alt.c cryp_aes_alt.c cryp_ccm_alt.c cryp_gcm_alt.c ecdh_alt.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c entropy_hardware_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c
  group oemirot
    ../../oemirot/: boot_hal_cfg.h boot_hal_flowcontrol.h boot_hal_hash_ref.c boot_hal_hash_ref.h boot_hal_imagevalid.h boot_hal_utils.h boot_hal.c boot_nv_counters.c cmsis.h flash_layout.h keys_map.c low_level_device.c low_level_flash.c low_level_flash.h low_level_rng.c low_level_rng.h low_level_security_config.h low_level_security.c low_level_security.h mcuboot_config.h region_defs.h tick.c
  group oemirot/generated/hal
    ../../oemirot/generated/hal/: mx_cortex_nvic.c mx_cortex_nvic.h mx_crc.c mx_crc.h mx_def.h mx_flash.c mx_flash.h mx_hal_def.h mx_hash.c mx_hash.h mx_icache.c mx_icache.h mx_pka.c mx_pka.h mx_ramcfg.c mx_ramcfg.h mx_rcc.c mx_rcc.h mx_rng.c mx_rng.h mx_saes.c mx_saes.h mx_sbs.c mx_sbs.h mx_system.c mx_system.h mx_tamp.c mx_tamp.h mx_usart2.c mx_usart2.h stm32_external_env.h stm32c5xx_hal_conf.h
  group oemirot/generated/middleware/stfcf
    ../../oemirot/generated/middleware/stfcf/: mx_mbedtls_alt_config.h mx_mbedtls_config.h mx_stfcf_config.h
  group oemirot/generated/utilities/basic_stdio
    ../../oemirot/generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group oemirot/user_modifiable/Device/STM32C5A3ZGT6
    ../../oemirot/user_modifiable/Device/STM32C5A3ZGT6/: startup_stm32c5a3xx.c system_stm32c5xx.c
  group stm32c5xx_dfp
    ../../../../../../../stm32c5xx_dfp/: README.md
  group stm32c5xx_dfp/Include
    ../../../../../../../stm32c5xx_dfp/Include/: stm32c5xx.h
  group stm32c5xx_drivers
    ../../../../../../../stm32c5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32c5xx_drivers/doc
    ../../../../../../../stm32c5xx_drivers/doc/: STMicroelectronics.stm32c5xx_hal_drivers_dependencies.md
  group stm32c5xx_drivers/hal
    ../../../../../../../stm32c5xx_drivers/hal/: stm32_hal.h stm32c5xx_hal_aes.c stm32c5xx_hal_aes.h stm32c5xx_hal_cortex.c stm32c5xx_hal_cortex.h stm32c5xx_hal_crc.c stm32c5xx_hal_crc.h stm32c5xx_hal_def.h stm32c5xx_hal_dma.c stm32c5xx_hal_dma.h stm32c5xx_hal_flash_itf.c stm32c5xx_hal_flash_itf.h stm32c5xx_hal_flash.c stm32c5xx_hal_flash.h stm32c5xx_hal_gpio.c stm32c5xx_hal_gpio.h stm32c5xx_hal_hash.c stm32c5xx_hal_hash.h stm32c5xx_hal_icache.c stm32c5xx_hal_icache.h stm32c5xx_hal_pka.c stm32c5xx_hal_pka.h stm32c5xx_hal_pwr.c stm32c5xx_hal_pwr.h stm32c5xx_hal_q.c stm32c5xx_hal_q.h stm32c5xx_hal_ramcfg.c stm32c5xx_hal_ramcfg.h stm32c5xx_hal_rcc.c stm32c5xx_hal_rcc.h stm32c5xx_hal_rng.c stm32c5xx_hal_rng.h stm32c5xx_hal_sbs.c stm32c5xx_hal_sbs.h stm32c5xx_hal_tamp.c stm32c5xx_hal_tamp.h stm32c5xx_hal_uart.c stm32c5xx_hal_uart.h stm32c5xx_hal.c stm32c5xx_hal.h
  group stm32c5xx_drivers/ll
    ../../../../../../../stm32c5xx_drivers/ll/: stm32c5xx_ll_bus.h stm32c5xx_ll_crc.h stm32c5xx_ll_dma.h stm32c5xx_ll_exti.h stm32c5xx_ll_flash.h stm32c5xx_ll_gpio.h stm32c5xx_ll_icache.h stm32c5xx_ll_pka.h stm32c5xx_ll_pwr.h stm32c5xx_ll_ramcfg.h stm32c5xx_ll_rcc.h stm32c5xx_ll_rng.h stm32c5xx_ll_sbs.h stm32c5xx_ll_tamp.h stm32c5xx_ll_usart.h stm32c5xx_ll_utils.h
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
