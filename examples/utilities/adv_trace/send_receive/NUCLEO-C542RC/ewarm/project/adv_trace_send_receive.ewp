# IAR project adv_trace_send_receive.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32C542RC ST STM32C542RC
  General.FPU2: 6
  ICCARM.CCDefines: STM32C542xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-C542RC/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../stm32c5xx_dfp/Include; ../../../../../../../stm32c5xx_drivers/hal; ../../../../../../../stm32c5xx_drivers/ll; ../../../../../../../stm32c5xx_drivers/timebases; ../../../../../../../utilities/advanced_trace/core; ../../../../../../../utilities/advanced_trace/interface_data; ../../../../../../../utilities/advanced_trace/templates; ../../../application; ../../generated/hal; ../../generated/utilities/advanced_trace; ../../user_modifiable/_release_IAR_NUCLEO-C542RC
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32C542xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32C542RCT6/stm32c542xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_usart2.c mx_usart2.h stm32_external_env.h stm32c5xx_hal_conf.h
  group generated/utilities/advanced_trace
    ../../generated/utilities/advanced_trace/: adv_trace_user_conf.h mx_advanced_trace_app.c mx_advanced_trace_app.h
  group stm32c5xx_dfp
    ../../../../../../../stm32c5xx_dfp/: README.md
  group stm32c5xx_dfp/Include
    ../../../../../../../stm32c5xx_dfp/Include/: stm32c5xx.h
  group stm32c5xx_drivers
    ../../../../../../../stm32c5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32c5xx_drivers/doc
    ../../../../../../../stm32c5xx_drivers/doc/: STMicroelectronics.stm32c5xx_hal_drivers_dependencies.md
  group stm32c5xx_drivers/hal
    ../../../../../../../stm32c5xx_drivers/hal/: stm32_hal.h stm32c5xx_hal_cortex.c stm32c5xx_hal_cortex.h stm32c5xx_hal_def.h stm32c5xx_hal_dma.c stm32c5xx_hal_dma.h stm32c5xx_hal_flash_itf.c stm32c5xx_hal_flash_itf.h stm32c5xx_hal_gpio.c stm32c5xx_hal_gpio.h stm32c5xx_hal_icache.c stm32c5xx_hal_icache.h stm32c5xx_hal_pwr.c stm32c5xx_hal_pwr.h stm32c5xx_hal_q.c stm32c5xx_hal_q.h stm32c5xx_hal_rcc.c stm32c5xx_hal_rcc.h stm32c5xx_hal_uart.c stm32c5xx_hal_uart.h stm32c5xx_hal.c stm32c5xx_hal.h
  group stm32c5xx_drivers/ll
    ../../../../../../../stm32c5xx_drivers/ll/: stm32c5xx_ll_bus.h stm32c5xx_ll_dma.h stm32c5xx_ll_exti.h stm32c5xx_ll_flash.h stm32c5xx_ll_gpio.h stm32c5xx_ll_icache.h stm32c5xx_ll_pwr.h stm32c5xx_ll_rcc.h stm32c5xx_ll_sbs.h stm32c5xx_ll_usart.h stm32c5xx_ll_utils.h
  group user_modifiable/Device/STM32C542RCT6
    ../../user_modifiable/Device/STM32C542RCT6/: startup_stm32c542xx.c system_stm32c5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/advanced_trace
    ../../../../../../../utilities/advanced_trace/: README.md SW_Security_Level.md
  group utilities/advanced_trace/core
    ../../../../../../../utilities/advanced_trace/core/: adv_trace_core.c adv_trace_core.h
  group utilities/advanced_trace/interface_data
    ../../../../../../../utilities/advanced_trace/interface_data/: adv_trace_itf_data.h adv_trace_itfdata_uart.c
  group utilities/advanced_trace/templates
    ../../../../../../../utilities/advanced_trace/templates/: adv_trace_user_conf_template.h
