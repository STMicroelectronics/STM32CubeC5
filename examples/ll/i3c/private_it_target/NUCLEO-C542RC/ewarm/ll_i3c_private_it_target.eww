<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_i3c_private_it_target.ewp</path>
    </project>
</workspace>