<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_dac_simple_conversion_trig_sw.ewp</path>
    </project>
</workspace>