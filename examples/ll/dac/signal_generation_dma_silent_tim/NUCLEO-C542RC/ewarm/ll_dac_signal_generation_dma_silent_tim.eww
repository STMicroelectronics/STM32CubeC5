<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_dac_signal_generation_dma_silent_tim.ewp</path>
    </project>
</workspace>