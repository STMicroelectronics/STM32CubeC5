<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_dac_sample_and_hold.ewp</path>
    </project>
</workspace>