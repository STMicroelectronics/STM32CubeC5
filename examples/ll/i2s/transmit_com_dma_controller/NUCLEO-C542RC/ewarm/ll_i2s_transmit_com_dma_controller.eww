<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_i2s_transmit_com_dma_controller.ewp</path>
    </project>
</workspace>