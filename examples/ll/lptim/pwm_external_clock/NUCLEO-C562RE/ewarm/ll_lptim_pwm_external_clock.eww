<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_lptim_pwm_external_clock.ewp</path>
    </project>
</workspace>