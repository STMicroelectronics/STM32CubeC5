<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_usart_two_boards_com_dma_responder.ewp</path>
    </project>
</workspace>