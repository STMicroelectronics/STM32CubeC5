<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_tamp_erase_backup_registers.ewp</path>
    </project>
</workspace>