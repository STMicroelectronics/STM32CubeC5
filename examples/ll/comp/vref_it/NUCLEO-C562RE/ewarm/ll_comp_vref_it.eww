<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_comp_vref_it.ewp</path>
    </project>
</workspace>