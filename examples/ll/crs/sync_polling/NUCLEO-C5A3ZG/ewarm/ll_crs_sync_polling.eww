<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_crs_sync_polling.ewp</path>
    </project>
</workspace>