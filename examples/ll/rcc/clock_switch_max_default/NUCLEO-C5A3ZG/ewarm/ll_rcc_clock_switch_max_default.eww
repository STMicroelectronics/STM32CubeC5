<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_rcc_clock_switch_max_default.ewp</path>
    </project>
</workspace>