<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_rtc_calib_output_frequency.ewp</path>
    </project>
</workspace>