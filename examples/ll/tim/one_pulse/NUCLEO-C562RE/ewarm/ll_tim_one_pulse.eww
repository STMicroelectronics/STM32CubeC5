<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_tim_one_pulse.ewp</path>
    </project>
</workspace>