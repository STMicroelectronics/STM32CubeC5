<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_tim_break_and_deadtime.ewp</path>
    </project>
</workspace>