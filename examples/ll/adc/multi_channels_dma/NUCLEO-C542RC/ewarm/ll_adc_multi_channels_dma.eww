<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_adc_multi_channels_dma.ewp</path>
    </project>
</workspace>