<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\ll_adc_temperature_sensor.ewp</path>
    </project>
</workspace>