<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_cordic_sincos_dma.ewp</path>
    </project>
</workspace>