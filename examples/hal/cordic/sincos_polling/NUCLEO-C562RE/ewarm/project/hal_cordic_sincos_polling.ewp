# IAR project hal_cordic_sincos_polling.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32C562RE ST STM32C562RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32C562xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-C562RE/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../arch/cmsis_dsp/Include; ../../../../../../../arch/cmsis_dsp/PrivateInclude; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32c5xx_dfp/Include; ../../../../../../../stm32c5xx_drivers/hal; ../../../../../../../stm32c5xx_drivers/ll; ../../../../../../../stm32c5xx_drivers/timebases; ../../../application; ../../generated/hal; ../../generated/parts/led; ../../user_modifiable/_release_IAR_NUCLEO-C562RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: STM32C562xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32C562RET6/stm32c562xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group arch/cmsis_dsp/Include
    ../../../../../../../arch/cmsis_dsp/Include/: arm_common_tables_f16.h arm_common_tables.h arm_const_structs_f16.h arm_const_structs.h arm_math_f16.h arm_math.h
  group arch/cmsis_dsp/Source/BasicMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group arch/cmsis_dsp/Source/BayesFunctions
    ../../../../../../../arch/cmsis_dsp/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group arch/cmsis_dsp/Source/CommonTables
    ../../../../../../../arch/cmsis_dsp/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group arch/cmsis_dsp/Source/ComplexMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group arch/cmsis_dsp/Source/ControllerFunctions
    ../../../../../../../arch/cmsis_dsp/Source/ControllerFunctions/: ControllerFunctions.c
  group arch/cmsis_dsp/Source/DistanceFunctions
    ../../../../../../../arch/cmsis_dsp/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
  group arch/cmsis_dsp/Source/FastMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group arch/cmsis_dsp/Source/FilteringFunctions
    ../../../../../../../arch/cmsis_dsp/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group arch/cmsis_dsp/Source/InterpolationFunctions
    ../../../../../../../arch/cmsis_dsp/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group arch/cmsis_dsp/Source/MatrixFunctions
    ../../../../../../../arch/cmsis_dsp/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group arch/cmsis_dsp/Source/QuaternionMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group arch/cmsis_dsp/Source/StatisticsFunctions
    ../../../../../../../arch/cmsis_dsp/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group arch/cmsis_dsp/Source/SupportFunctions
    ../../../../../../../arch/cmsis_dsp/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group arch/cmsis_dsp/Source/SVMFunctions
    ../../../../../../../arch/cmsis_dsp/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group arch/cmsis_dsp/Source/TransformFunctions
    ../../../../../../../arch/cmsis_dsp/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group arch/cmsis_dsp/Source/WindowFunctions
    ../../../../../../../arch/cmsis_dsp/Source/WindowFunctions/: WindowFunctions.c
  group generated/hal
    ../../generated/hal/: mx_cordic.c mx_cordic.h mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h stm32_external_env.h stm32c5xx_hal_conf.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32c5xx_dfp
    ../../../../../../../stm32c5xx_dfp/: README.md
  group stm32c5xx_dfp/Include
    ../../../../../../../stm32c5xx_dfp/Include/: stm32c5xx.h
  group stm32c5xx_drivers
    ../../../../../../../stm32c5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32c5xx_drivers/doc
    ../../../../../../../stm32c5xx_drivers/doc/: STMicroelectronics.stm32c5xx_hal_drivers_dependencies.md
  group stm32c5xx_drivers/hal
    ../../../../../../../stm32c5xx_drivers/hal/: stm32_hal.h stm32c5xx_hal_cordic.c stm32c5xx_hal_cordic.h stm32c5xx_hal_cortex.c stm32c5xx_hal_cortex.h stm32c5xx_hal_def.h stm32c5xx_hal_dma.c stm32c5xx_hal_dma.h stm32c5xx_hal_flash_itf.c stm32c5xx_hal_flash_itf.h stm32c5xx_hal_flash.c stm32c5xx_hal_flash.h stm32c5xx_hal_gpio.c stm32c5xx_hal_gpio.h stm32c5xx_hal_icache.c stm32c5xx_hal_icache.h stm32c5xx_hal_pwr.c stm32c5xx_hal_pwr.h stm32c5xx_hal_q.c stm32c5xx_hal_q.h stm32c5xx_hal_rcc.c stm32c5xx_hal_rcc.h stm32c5xx_hal.c stm32c5xx_hal.h
  group stm32c5xx_drivers/ll
    ../../../../../../../stm32c5xx_drivers/ll/: stm32c5xx_ll_bus.h stm32c5xx_ll_cordic.h stm32c5xx_ll_dma.h stm32c5xx_ll_exti.h stm32c5xx_ll_flash.h stm32c5xx_ll_gpio.h stm32c5xx_ll_icache.h stm32c5xx_ll_pwr.h stm32c5xx_ll_rcc.h stm32c5xx_ll_sbs.h stm32c5xx_ll_utils.h
  group user_modifiable/Device/STM32C562RET6
    ../../user_modifiable/Device/STM32C562RET6/: startup_stm32c562xx.c system_stm32c5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
