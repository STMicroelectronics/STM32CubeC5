<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_hash_auth_2keys_hmac_sha_suspension.ewp</path>
    </project>
</workspace>