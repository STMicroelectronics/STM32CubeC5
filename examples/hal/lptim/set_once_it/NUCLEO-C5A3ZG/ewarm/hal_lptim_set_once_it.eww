<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_lptim_set_once_it.ewp</path>
    </project>
</workspace>