<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_ccb_protected_edsca_blob_creation.ewp</path>
    </project>
</workspace>