<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_ccb_protected_ecc_scalar_mul_blob_use.ewp</path>
    </project>
</workspace>