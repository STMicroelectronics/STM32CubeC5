<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_ccb_protected_rsa_modular_exp_blob_creation.ewp</path>
    </project>
</workspace>