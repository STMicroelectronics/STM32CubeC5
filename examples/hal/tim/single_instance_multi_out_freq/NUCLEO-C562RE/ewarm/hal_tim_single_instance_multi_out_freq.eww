<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_tim_single_instance_multi_out_freq.ewp</path>
    </project>
</workspace>