<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_tim_6_step_pwm.ewp</path>
    </project>
</workspace>