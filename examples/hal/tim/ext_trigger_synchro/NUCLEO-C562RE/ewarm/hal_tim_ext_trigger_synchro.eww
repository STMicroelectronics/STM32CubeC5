<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_tim_ext_trigger_synchro.ewp</path>
    </project>
</workspace>