<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_i3c_ibi_wakeup_from_stop_controller.ewp</path>
    </project>
</workspace>