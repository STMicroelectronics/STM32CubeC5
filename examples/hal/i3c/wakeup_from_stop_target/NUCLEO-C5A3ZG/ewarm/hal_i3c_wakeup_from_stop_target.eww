<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_i3c_wakeup_from_stop_target.ewp</path>
    </project>
</workspace>