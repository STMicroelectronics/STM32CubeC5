<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_i3c_direct_dma_target.ewp</path>
    </project>
</workspace>