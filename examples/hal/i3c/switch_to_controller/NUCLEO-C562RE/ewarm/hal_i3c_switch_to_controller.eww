<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_i3c_switch_to_controller.ewp</path>
    </project>
</workspace>