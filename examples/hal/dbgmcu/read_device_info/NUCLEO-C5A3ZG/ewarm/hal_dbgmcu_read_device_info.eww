<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_dbgmcu_read_device_info.ewp</path>
    </project>
</workspace>