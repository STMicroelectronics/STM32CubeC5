<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_flash_write_protection.ewp</path>
    </project>
</workspace>