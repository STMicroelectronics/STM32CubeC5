<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_flash_swap_bank2.ewp</path>
    </project>
</workspace>