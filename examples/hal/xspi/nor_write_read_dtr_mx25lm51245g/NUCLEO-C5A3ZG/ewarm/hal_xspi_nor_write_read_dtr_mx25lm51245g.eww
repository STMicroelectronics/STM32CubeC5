<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_xspi_nor_write_read_dtr_mx25lm51245g.ewp</path>
    </project>
</workspace>