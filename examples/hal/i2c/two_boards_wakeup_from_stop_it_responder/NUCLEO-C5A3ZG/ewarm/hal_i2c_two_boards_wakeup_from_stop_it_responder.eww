<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_i2c_two_boards_wakeup_from_stop_it_responder.ewp</path>
    </project>
</workspace>