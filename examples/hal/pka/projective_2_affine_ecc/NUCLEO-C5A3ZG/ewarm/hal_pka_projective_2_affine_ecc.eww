<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_pka_projective_2_affine_ecc.ewp</path>
    </project>
</workspace>