<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_pka_scalar_multiplication_ecc_it.ewp</path>
    </project>
</workspace>