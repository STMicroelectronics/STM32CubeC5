<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_pka_modular_exponentiation_protected.ewp</path>
    </project>
</workspace>