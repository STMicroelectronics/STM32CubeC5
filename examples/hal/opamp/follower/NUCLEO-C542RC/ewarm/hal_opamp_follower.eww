<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_opamp_follower.ewp</path>
    </project>
</workspace>