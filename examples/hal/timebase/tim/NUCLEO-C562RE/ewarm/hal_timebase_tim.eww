<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_timebase_tim.ewp</path>
    </project>
</workspace>