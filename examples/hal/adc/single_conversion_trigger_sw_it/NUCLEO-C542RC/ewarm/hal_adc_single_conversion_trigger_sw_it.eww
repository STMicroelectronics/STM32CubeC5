<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_adc_single_conversion_trigger_sw_it.ewp</path>
    </project>
</workspace>