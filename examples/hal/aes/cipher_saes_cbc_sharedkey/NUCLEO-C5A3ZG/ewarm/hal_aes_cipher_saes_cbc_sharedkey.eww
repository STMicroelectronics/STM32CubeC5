<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_aes_cipher_saes_cbc_sharedkey.ewp</path>
    </project>
</workspace>