<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_spi_adc_com_polling.ewp</path>
    </project>
</workspace>