<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_dma_trigger.ewp</path>
    </project>
</workspace>