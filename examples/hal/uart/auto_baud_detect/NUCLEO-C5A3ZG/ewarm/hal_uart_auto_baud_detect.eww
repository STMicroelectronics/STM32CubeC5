<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_uart_auto_baud_detect.ewp</path>
    </project>
</workspace>