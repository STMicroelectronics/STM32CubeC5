<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_uart_wakeup_from_stop.ewp</path>
    </project>
</workspace>