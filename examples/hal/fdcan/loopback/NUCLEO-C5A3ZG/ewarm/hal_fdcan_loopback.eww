<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_fdcan_loopback.ewp</path>
    </project>
</workspace>