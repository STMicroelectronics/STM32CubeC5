<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\filex_nand_rw_file_no_os.ewp</path>
    </project>
</workspace>