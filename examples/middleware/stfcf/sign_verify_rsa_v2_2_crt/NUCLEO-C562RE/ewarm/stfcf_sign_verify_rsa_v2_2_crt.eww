<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stfcf_sign_verify_rsa_v2_2_crt.ewp</path>
    </project>
</workspace>