<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stfcf_wrapped_key_gen_ecc_ecdsa.ewp</path>
    </project>
</workspace>