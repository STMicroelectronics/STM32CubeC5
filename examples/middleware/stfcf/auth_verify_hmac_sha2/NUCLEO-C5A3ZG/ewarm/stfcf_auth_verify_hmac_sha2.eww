<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stfcf_auth_verify_hmac_sha2.ewp</path>
    </project>
</workspace>