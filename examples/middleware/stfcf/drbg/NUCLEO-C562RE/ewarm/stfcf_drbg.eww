<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stfcf_drbg.ewp</path>
    </project>
</workspace>