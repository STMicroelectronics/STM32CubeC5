<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stfcf_integrity_hash_sha2.ewp</path>
    </project>
</workspace>