<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stfcf_shared_secret_gen_ecc_ecdh.ewp</path>
    </project>
</workspace>