<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stfcf_auth_verify_aes_cmac.ewp</path>
    </project>
</workspace>