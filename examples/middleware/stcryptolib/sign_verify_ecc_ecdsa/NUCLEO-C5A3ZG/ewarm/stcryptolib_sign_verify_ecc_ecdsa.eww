<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stcryptolib_sign_verify_ecc_ecdsa.ewp</path>
    </project>
</workspace>