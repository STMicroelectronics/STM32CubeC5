# IAR project stcryptolib_sign_verify_ecc_sm2.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32C5A3ZG ST STM32C5A3ZG
  General.FPU2: 6
  ICCARM.CCDefines: STM32C5A3xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-C5A3ZG/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/stcryptolib/include; ../../../../../../../middleware/stcryptolib/include/cipher; ../../../../../../../middleware/stcryptolib/include/drbg; ../../../../../../../middleware/stcryptolib/include/ecc; ../../../../../../../middleware/stcryptolib/include/hash; ../../../../../../../middleware/stcryptolib/include/mac; ../../../../../../../middleware/stcryptolib/include/rsa; ../../../../../../../middleware/stcryptolib/include/utils; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32c5xx_dfp/Include; ../../../../../../../stm32c5xx_drivers/hal; ../../../../../../../stm32c5xx_drivers/ll; ../../../../../../../stm32c5xx_drivers/timebases; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/hal; ../../generated/middleware/stcryptolib; ../../generated/parts/led; ../../generated/utilities/basic_stdio; ../../user_modifiable/_release_IAR_NUCLEO-C5A3ZG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32C5A3xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32C5A3ZGT6/stm32c5a3xg_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_crc.c mx_crc.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_rng.c mx_rng.h mx_system.c mx_system.h mx_usart2.c mx_usart2.h stm32_external_env.h stm32c5xx_hal_conf.h
  group generated/middleware/stcryptolib
    ../../generated/middleware/stcryptolib/: mx_cmox_config.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/utilities/basic_stdio
    ../../generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group middleware/stcryptolib
    ../../../../../../../middleware/stcryptolib/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group middleware/stcryptolib/include
    ../../../../../../../middleware/stcryptolib/include/: cmox_common.h cmox_crypto.h cmox_cta.h cmox_default_config.h cmox_default_defs.h cmox_info.h cmox_init.h cmox_low_level.h
  group middleware/stcryptolib/include/cipher
    ../../../../../../../middleware/stcryptolib/include/cipher/: cmox_blockcipher.h cmox_cbc.h cmox_ccm.h cmox_cfb.h cmox_chachapoly.h cmox_check_default_aes.h cmox_check_default_gcm.h cmox_cipher_retvals.h cmox_cipher.h cmox_ctr.h cmox_ecb.h cmox_gcm.h cmox_keywrap.h cmox_ofb.h cmox_xts.h
  group middleware/stcryptolib/include/drbg
    ../../../../../../../middleware/stcryptolib/include/drbg/: cmox_ctr_drbg.h cmox_drbg_retvals.h cmox_drbg.h
  group middleware/stcryptolib/include/ecc
    ../../../../../../../middleware/stcryptolib/include/ecc/: cmox_ecc_custom_curves.h cmox_ecc_retvals.h cmox_ecc_types.h cmox_ecc.h cmox_ecdh.h cmox_ecdsa.h cmox_eddsa.h cmox_sm2.h
  group middleware/stcryptolib/include/hash
    ../../../../../../../middleware/stcryptolib/include/hash/: cmox_hash_retvals.h cmox_hash.h cmox_md.h cmox_sha1.h cmox_sha224.h cmox_sha256.h cmox_sha3.h cmox_sha384.h cmox_sha512.h cmox_sm3.h cmox_sponge.h
  group middleware/stcryptolib/include/mac
    ../../../../../../../middleware/stcryptolib/include/mac/: cmox_cmac.h cmox_hmac.h cmox_kmac.h cmox_mac_retvals.h cmox_mac.h
  group middleware/stcryptolib/include/rsa
    ../../../../../../../middleware/stcryptolib/include/rsa/: cmox_rsa_pkcs1v15.h cmox_rsa_pkcs1v22.h cmox_rsa_retvals.h cmox_rsa_types.h cmox_rsa.h
  group middleware/stcryptolib/include/utils
    ../../../../../../../middleware/stcryptolib/include/utils/: cmox_utils_compare.h cmox_utils_retvals.h
  group middleware/stcryptolib/lib
    ../../../../../../../middleware/stcryptolib/lib/: libSTM32Cryptographic_CM33.a
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32c5xx_dfp
    ../../../../../../../stm32c5xx_dfp/: README.md
  group stm32c5xx_dfp/Include
    ../../../../../../../stm32c5xx_dfp/Include/: stm32c5xx.h
  group stm32c5xx_drivers
    ../../../../../../../stm32c5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32c5xx_drivers/doc
    ../../../../../../../stm32c5xx_drivers/doc/: STMicroelectronics.stm32c5xx_hal_drivers_dependencies.md
  group stm32c5xx_drivers/hal
    ../../../../../../../stm32c5xx_drivers/hal/: stm32_hal.h stm32c5xx_hal_cortex.c stm32c5xx_hal_cortex.h stm32c5xx_hal_crc.c stm32c5xx_hal_crc.h stm32c5xx_hal_def.h stm32c5xx_hal_dma.c stm32c5xx_hal_dma.h stm32c5xx_hal_flash_itf.c stm32c5xx_hal_flash_itf.h stm32c5xx_hal_gpio.c stm32c5xx_hal_gpio.h stm32c5xx_hal_icache.c stm32c5xx_hal_icache.h stm32c5xx_hal_pwr.c stm32c5xx_hal_pwr.h stm32c5xx_hal_q.c stm32c5xx_hal_q.h stm32c5xx_hal_rcc.c stm32c5xx_hal_rcc.h stm32c5xx_hal_rng.c stm32c5xx_hal_rng.h stm32c5xx_hal_uart.c stm32c5xx_hal_uart.h stm32c5xx_hal.c stm32c5xx_hal.h
  group stm32c5xx_drivers/ll
    ../../../../../../../stm32c5xx_drivers/ll/: stm32c5xx_ll_bus.h stm32c5xx_ll_crc.h stm32c5xx_ll_dma.h stm32c5xx_ll_exti.h stm32c5xx_ll_flash.h stm32c5xx_ll_gpio.h stm32c5xx_ll_icache.h stm32c5xx_ll_pwr.h stm32c5xx_ll_rcc.h stm32c5xx_ll_rng.h stm32c5xx_ll_sbs.h stm32c5xx_ll_usart.h stm32c5xx_ll_utils.h
  group user_modifiable/Device/STM32C5A3ZGT6
    ../../user_modifiable/Device/STM32C5A3ZGT6/: startup_stm32c5a3xx.c system_stm32c5xx.c
  group user_modifiable/Security
    ../../user_modifiable/Security/: cmox_low_level.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
