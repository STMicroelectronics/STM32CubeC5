<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stcryptolib_sign_verify_rsa_v1_5.ewp</path>
    </project>
</workspace>