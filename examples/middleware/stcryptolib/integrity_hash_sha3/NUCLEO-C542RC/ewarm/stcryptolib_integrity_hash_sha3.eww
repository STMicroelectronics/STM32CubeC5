<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stcryptolib_integrity_hash_sha3.ewp</path>
    </project>
</workspace>