<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\stcryptolib_auth_verify_kmac.ewp</path>
    </project>
</workspace>