# IAR project usbx_device_hid_mouse_no_os.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32C562RE ST STM32C562RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32C562xx; USBD_INCLUDE_USER_DESC_CONFIG_FILE; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-C562RE/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/usbx/common/core/inc; ../../../../../../../middleware/usbx/common/usbx_device_classes/inc; ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_controllers; ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_descriptors; ../../../../../../../middleware/usbx/ports/generic/inc; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32c5xx_dfp/Include; ../../../../../../../stm32c5xx_drivers/hal; ../../../../../../../stm32c5xx_drivers/ll; ../../../../../../../stm32c5xx_drivers/timebases; ../../../application; ../../generated/hal; ../../generated/middleware/usbx; ../../generated/parts/led; ../../user_modifiable/_release_IAR_NUCLEO-C562RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32C562xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32C562RET6/stm32c562xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_crs.c mx_crs.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_usb_drd_fs.c mx_usb_drd_fs.h stm32_external_env.h stm32c5xx_hal_conf.h
  group generated/middleware/usbx
    ../../generated/middleware/usbx/: mx_usbx_app.c mx_usbx_app.h mx_usbx_device_hid_mouse.c mx_usbx_device_hid_mouse.h mx_usbx_device.c mx_usbx_device.h ux_stm32_device_descriptors_config.h ux_user.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group middleware/usbx
    ../../../../../../../middleware/usbx/: README.md ST_Release_Notes.md SW_Security_Level.md
  group middleware/usbx/common/core/inc
    ../../../../../../../middleware/usbx/common/core/inc/: ux_api.h ux_dcd_sim_slave.h ux_device_class_dpump.h ux_device_stack.h ux_system.h ux_utility.h
  group middleware/usbx/common/core/src
    ../../../../../../../middleware/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_long_get_big_endian.c ux_utility_long_get.c ux_utility_long_put_big_endian.c ux_utility_long_put.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_allocate.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free_block_best_get.c ux_utility_memory_free.c ux_utility_memory_set.c ux_utility_physical_address.c ux_utility_set_interrupt_handler.c ux_utility_short_get_big_endian.c ux_utility_short_get.c ux_utility_short_put_big_endian.c ux_utility_short_put.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group middleware/usbx/common/usbx_device_classes/inc
    ../../../../../../../middleware/usbx/common/usbx_device_classes/inc/: ux_device_class_hid.h
  group middleware/usbx/common/usbx_device_classes/src
    ../../../../../../../middleware/usbx/common/usbx_device_classes/src/: ux_device_class_hid_activate.c ux_device_class_hid_control_request.c ux_device_class_hid_deactivate.c ux_device_class_hid_descriptor_send.c ux_device_class_hid_entry.c ux_device_class_hid_event_get.c ux_device_class_hid_event_set.c ux_device_class_hid_initialize.c ux_device_class_hid_read_run.c ux_device_class_hid_receiver_event_free.c ux_device_class_hid_receiver_event_get.c ux_device_class_hid_receiver_initialize.c ux_device_class_hid_receiver_tasks_run.c ux_device_class_hid_receiver_uninitialize.c ux_device_class_hid_report_get.c ux_device_class_hid_report_set.c ux_device_class_hid_tasks_run.c ux_device_class_hid_uninitialize.c
  group middleware/usbx/interfaces/usbx_stm32_device_controllers
    ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_initialize.c ux_dcd_stm32_register_callback.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c ux_dcd_stm32.h
  group middleware/usbx/interfaces/usbx_stm32_device_descriptors
    ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_descriptors/: ux_stm32_device_descriptors.c ux_stm32_device_descriptors.h
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32c5xx_dfp
    ../../../../../../../stm32c5xx_dfp/: README.md
  group stm32c5xx_dfp/Include
    ../../../../../../../stm32c5xx_dfp/Include/: stm32c5xx.h
  group stm32c5xx_drivers
    ../../../../../../../stm32c5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32c5xx_drivers/doc
    ../../../../../../../stm32c5xx_drivers/doc/: STMicroelectronics.stm32c5xx_hal_drivers_dependencies.md
  group stm32c5xx_drivers/hal
    ../../../../../../../stm32c5xx_drivers/hal/: stm32_hal.h stm32c5xx_hal_cortex.c stm32c5xx_hal_cortex.h stm32c5xx_hal_crs.c stm32c5xx_hal_crs.h stm32c5xx_hal_def.h stm32c5xx_hal_exti.c stm32c5xx_hal_exti.h stm32c5xx_hal_flash_itf.c stm32c5xx_hal_flash_itf.h stm32c5xx_hal_gpio.c stm32c5xx_hal_gpio.h stm32c5xx_hal_icache.c stm32c5xx_hal_icache.h stm32c5xx_hal_pcd.c stm32c5xx_hal_pcd.h stm32c5xx_hal_pwr.c stm32c5xx_hal_pwr.h stm32c5xx_hal_rcc.c stm32c5xx_hal_rcc.h stm32c5xx_hal.c stm32c5xx_hal.h stm32c5xx_usb_core_def.h stm32c5xx_usb_drd_core.c stm32c5xx_usb_drd_core.h
  group stm32c5xx_drivers/ll
    ../../../../../../../stm32c5xx_drivers/ll/: stm32c5xx_ll_bus.h stm32c5xx_ll_crs.h stm32c5xx_ll_exti.h stm32c5xx_ll_flash.h stm32c5xx_ll_gpio.h stm32c5xx_ll_icache.h stm32c5xx_ll_pwr.h stm32c5xx_ll_rcc.h stm32c5xx_ll_sbs.h stm32c5xx_ll_utils.h
  group user_modifiable/Device/STM32C562RET6
    ../../user_modifiable/Device/STM32C562RET6/: startup_stm32c562xx.c system_stm32c5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
