<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\usbx_device_hid_mouse_freertos.ewp</path>
    </project>
</workspace>