<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\usbx_host_hub_msc_hid_freertos.ewp</path>
    </project>
</workspace>