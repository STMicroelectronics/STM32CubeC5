<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\levelx_nand_multi_access_freertos.ewp</path>
    </project>
</workspace>