<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\levelx_nor_rw_data_no_os.ewp</path>
    </project>
</workspace>