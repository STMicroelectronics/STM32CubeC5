<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\freertos_message_queue.ewp</path>
    </project>
</workspace>