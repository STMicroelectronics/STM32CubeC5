<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\freertos_task_privilege.ewp</path>
    </project>
</workspace>