# IAR project lwip_iperf_freertos.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32C5A3ZG ST STM32C5A3ZG
  General.FPU2: 6
  ICCARM.CCDefines: STM32C5A3xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-C5A3ZG/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/freertos/include; ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../middleware/lwip/interfaces/ethernet; ../../../../../../../middleware/lwip/ports; ../../../../../../../middleware/lwip/ports/common; ../../../../../../../middleware/lwip/ports/common/arch; ../../../../../../../middleware/lwip/ports/freertos; ../../../../../../../middleware/lwip/ports/freertos/arch; ../../../../../../../middleware/lwip/src/include; ../../../../../../../middleware/lwip/src/include/compat; ../../../../../../../middleware/lwip/src/include/compat/posix; ../../../../../../../middleware/lwip/src/include/compat/posix/arpa; ../../../../../../../middleware/lwip/src/include/compat/posix/net; ../../../../../../../middleware/lwip/src/include/compat/posix/sys; ../../../../../../../middleware/lwip/src/include/compat/stdc; ../../../../../../../middleware/lwip/src/include/lwip; ../../../../../../../middleware/lwip/src/include/lwip/apps; ../../../../../../../middleware/lwip/src/include/lwip/priv; ../../../../../../../middleware/lwip/src/include/lwip/prot; ../../../../../../../middleware/lwip/src/include/netif; ../../../../../../../part_drivers/lan8742; ../../../../../../../part_drivers/lan8742/interfaces/eth; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32c5xx_dfp/Include; ../../../../../../../stm32c5xx_drivers/hal; ../../../../../../../stm32c5xx_drivers/ll; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/hal; ../../generated/middleware/freertos; ../../generated/middleware/lwip; ../../generated/parts/lan8742; ../../generated/parts/led; ../../generated/utilities/basic_stdio; ../../user_modifiable/_release_IAR_NUCLEO-C5A3ZG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32C5A3xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32C5A3ZGT6/stm32c5a3xg_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example_lwip_iperf_freertos
    ../../../application/: app_config.h app_iperf_tcp_server.c app_iperf_tcp_server.h app_logger.c app_logger.h app_lwip.c app_lwip.h
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_eth1.c mx_eth1.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_rng.c mx_rng.h mx_system.c mx_system.h mx_tim6.c mx_tim6.h mx_usart2.c mx_usart2.h stm32_external_env.h stm32_hal_timebase.h stm32c5xx_hal_conf.h
  group generated/middleware/freertos
    ../../generated/middleware/freertos/: FreeRTOSConfig.h mx_freertos_app.c mx_freertos_app.h
  group generated/middleware/lwip
    ../../generated/middleware/lwip/: lwipopts.h mx_lwip_phy.h mx_lwip.c mx_lwip.h
  group generated/parts/lan8742
    ../../generated/parts/lan8742/: mx_lan8742.c mx_lan8742.h mx_phy1.c mx_phy1.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/utilities/basic_stdio
    ../../generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group middleware/freertos
    ../../../../../../../middleware/freertos/: croutine.c event_groups.c list.c queue.c README.md ST_Release_Notes.md SW_Security_Level.md tasks.c timers.c
  group middleware/freertos/include
    ../../../../../../../middleware/freertos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group middleware/freertos/portable/Common
    ../../../../../../../middleware/freertos/portable/Common/: mpu_wrappers.c
  group middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../../middleware/freertos/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group middleware/freertos/portable/MemMang
    ../../../../../../../middleware/freertos/portable/MemMang/: heap_4.c
  group middleware/lwip
    ../../../../../../../middleware/lwip/: SW_Security_Level.md
  group middleware/lwip/interfaces/ethernet
    ../../../../../../../middleware/lwip/interfaces/ethernet/: eth_interface_freertos.c eth_interface_freertos.h
  group middleware/lwip/ports/common/arch
    ../../../../../../../middleware/lwip/ports/common/arch/: bpstruct.h cc.h epstruct.h init.h perf.h
  group middleware/lwip/ports/freertos/arch
    ../../../../../../../middleware/lwip/ports/freertos/arch/: sys_arch.c sys_arch.h
  group middleware/lwip/src/api
    ../../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group middleware/lwip/src/apps/lwiperf
    ../../../../../../../middleware/lwip/src/apps/lwiperf/: lwiperf.c
  group middleware/lwip/src/apps/mdns
    ../../../../../../../middleware/lwip/src/apps/mdns/: mdns_domain.c mdns_out.c mdns.c
  group middleware/lwip/src/core
    ../../../../../../../middleware/lwip/src/core/: altcp_alloc.c altcp_tcp.c altcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp_in.c tcp_out.c tcp.c timeouts.c udp.c
  group middleware/lwip/src/core/ipv4
    ../../../../../../../middleware/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_addr.c ip4_frag.c ip4.c
  group middleware/lwip/src/core/ipv6
    ../../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6_addr.c ip6_frag.c ip6.c mld6.c nd6.c
  group middleware/lwip/src/include/lwip
    ../../../../../../../middleware/lwip/src/include/lwip/: api.h dhcp.h dhcp6.h dns.h netif.h sockets.h tcpip.h
  group middleware/lwip/src/include/netif
    ../../../../../../../middleware/lwip/src/include/netif/: ethernet.h
  group middleware/lwip/src/netif
    ../../../../../../../middleware/lwip/src/netif/: ethernet.c
  group part_drivers/lan8742
    ../../../../../../../part_drivers/lan8742/: lan8742.c lan8742.h LICENSE.md README.md SW_Security_Level.md
  group part_drivers/lan8742/interfaces/eth
    ../../../../../../../part_drivers/lan8742/interfaces/eth/: lan8742_io.c lan8742_io.h
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32c5xx_dfp
    ../../../../../../../stm32c5xx_dfp/: README.md
  group stm32c5xx_dfp/Include
    ../../../../../../../stm32c5xx_dfp/Include/: stm32c5xx.h
  group stm32c5xx_drivers
    ../../../../../../../stm32c5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32c5xx_drivers/doc
    ../../../../../../../stm32c5xx_drivers/doc/: STMicroelectronics.stm32c5xx_hal_drivers_dependencies.md
  group stm32c5xx_drivers/hal
    ../../../../../../../stm32c5xx_drivers/hal/: stm32_hal.h stm32c5xx_hal_cortex.c stm32c5xx_hal_cortex.h stm32c5xx_hal_def.h stm32c5xx_hal_dma.c stm32c5xx_hal_dma.h stm32c5xx_hal_eth.c stm32c5xx_hal_eth.h stm32c5xx_hal_exti.c stm32c5xx_hal_exti.h stm32c5xx_hal_flash_itf.c stm32c5xx_hal_flash_itf.h stm32c5xx_hal_gpio.c stm32c5xx_hal_gpio.h stm32c5xx_hal_icache.c stm32c5xx_hal_icache.h stm32c5xx_hal_pwr.c stm32c5xx_hal_pwr.h stm32c5xx_hal_q.c stm32c5xx_hal_q.h stm32c5xx_hal_rcc.c stm32c5xx_hal_rcc.h stm32c5xx_hal_rng.c stm32c5xx_hal_rng.h stm32c5xx_hal_tim.c stm32c5xx_hal_tim.h stm32c5xx_hal_uart.c stm32c5xx_hal_uart.h stm32c5xx_hal.c stm32c5xx_hal.h
  group stm32c5xx_drivers/ll
    ../../../../../../../stm32c5xx_drivers/ll/: stm32c5xx_ll_bus.h stm32c5xx_ll_dma.h stm32c5xx_ll_exti.h stm32c5xx_ll_flash.h stm32c5xx_ll_gpio.h stm32c5xx_ll_icache.h stm32c5xx_ll_pwr.h stm32c5xx_ll_rcc.h stm32c5xx_ll_rng.h stm32c5xx_ll_sbs.h stm32c5xx_ll_tim.h stm32c5xx_ll_usart.h stm32c5xx_ll_utils.h
  group stm32c5xx_drivers/timebases
    ../../../../../../../stm32c5xx_drivers/timebases/: stm32_hal_timebase_tim.c
  group user_modifiable/Device/STM32C5A3ZGT6
    ../../user_modifiable/Device/STM32C5A3ZGT6/: startup_stm32c5a3xx.c system_stm32c5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
