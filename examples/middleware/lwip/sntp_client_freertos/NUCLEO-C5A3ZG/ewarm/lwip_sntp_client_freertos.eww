<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\lwip_sntp_client_freertos.ewp</path>
    </project>
</workspace>