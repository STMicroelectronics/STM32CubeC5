<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\lwip_tcp_echo_freertos.ewp</path>
    </project>
</workspace>