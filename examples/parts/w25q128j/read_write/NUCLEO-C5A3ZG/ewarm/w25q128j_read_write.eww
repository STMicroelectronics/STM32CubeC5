<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\w25q128j_read_write.ewp</path>
    </project>
</workspace>