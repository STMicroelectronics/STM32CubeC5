<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\led_blinking_pwm.ewp</path>
    </project>
</workspace>