<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\button_async_gpio_control.ewp</path>
    </project>
</workspace>