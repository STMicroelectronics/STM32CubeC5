<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\lps22hh_datalog_i2c.ewp</path>
    </project>
</workspace>