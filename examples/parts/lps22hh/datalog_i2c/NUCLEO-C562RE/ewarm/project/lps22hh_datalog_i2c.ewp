# IAR project lps22hh_datalog_i2c.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32C562RE ST STM32C562RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32C562xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-C562RE/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../part_drivers/led/gpio; ../../../../../../../part_drivers/lps22hh; ../../../../../../../part_drivers/lps22hh/interfaces/i2c; ../../../../../../../part_drivers/lps22hh/regs; ../../../../../../../stm32c5xx_dfp/Include; ../../../../../../../stm32c5xx_drivers/hal; ../../../../../../../stm32c5xx_drivers/ll; ../../../../../../../stm32c5xx_drivers/timebases; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/hal; ../../generated/parts/led; ../../generated/parts/lps22hh; ../../generated/utilities/basic_stdio; ../../user_modifiable/_release_IAR_NUCLEO-C562RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32C562xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32C562RET6/stm32c562xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_i2c1.c mx_i2c1.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_usart2.c mx_usart2.h stm32_external_env.h stm32c5xx_hal_conf.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/parts/lps22hh
    ../../generated/parts/lps22hh/: mx_lps22hh.c mx_lps22hh.h
  group generated/utilities/basic_stdio
    ../../generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group part_drivers/lps22hh
    ../../../../../../../part_drivers/lps22hh/: CONTRIBUTING.md lps22hh.c lps22hh.h README.md SW_Security_Level.md
  group part_drivers/lps22hh/interfaces/i2c
    ../../../../../../../part_drivers/lps22hh/interfaces/i2c/: lps22hh_io.c lps22hh_io.h
  group part_drivers/lps22hh/regs
    ../../../../../../../part_drivers/lps22hh/regs/: lps22hh_reg.c lps22hh_reg.h
  group stm32c5xx_dfp
    ../../../../../../../stm32c5xx_dfp/: README.md
  group stm32c5xx_dfp/Include
    ../../../../../../../stm32c5xx_dfp/Include/: stm32c5xx.h
  group stm32c5xx_drivers
    ../../../../../../../stm32c5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32c5xx_drivers/doc
    ../../../../../../../stm32c5xx_drivers/doc/: STMicroelectronics.stm32c5xx_hal_drivers_dependencies.md
  group stm32c5xx_drivers/hal
    ../../../../../../../stm32c5xx_drivers/hal/: stm32_hal.h stm32c5xx_hal_cortex.c stm32c5xx_hal_cortex.h stm32c5xx_hal_def.h stm32c5xx_hal_dma.c stm32c5xx_hal_dma.h stm32c5xx_hal_exti.c stm32c5xx_hal_exti.h stm32c5xx_hal_flash_itf.c stm32c5xx_hal_flash_itf.h stm32c5xx_hal_gpio.c stm32c5xx_hal_gpio.h stm32c5xx_hal_i2c.c stm32c5xx_hal_i2c.h stm32c5xx_hal_icache.c stm32c5xx_hal_icache.h stm32c5xx_hal_pwr.c stm32c5xx_hal_pwr.h stm32c5xx_hal_q.c stm32c5xx_hal_q.h stm32c5xx_hal_rcc.c stm32c5xx_hal_rcc.h stm32c5xx_hal_uart.c stm32c5xx_hal_uart.h stm32c5xx_hal.c stm32c5xx_hal.h
  group stm32c5xx_drivers/ll
    ../../../../../../../stm32c5xx_drivers/ll/: stm32c5xx_ll_bus.h stm32c5xx_ll_dma.h stm32c5xx_ll_exti.h stm32c5xx_ll_flash.h stm32c5xx_ll_gpio.h stm32c5xx_ll_i2c.h stm32c5xx_ll_icache.h stm32c5xx_ll_pwr.h stm32c5xx_ll_rcc.h stm32c5xx_ll_sbs.h stm32c5xx_ll_usart.h stm32c5xx_ll_utils.h
  group user_modifiable/Device/STM32C562RET6
    ../../user_modifiable/Device/STM32C562RET6/: startup_stm32c562xx.c system_stm32c5xx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
