<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\template_start_from_nucleo.ewp</path>
    </project>
</workspace>