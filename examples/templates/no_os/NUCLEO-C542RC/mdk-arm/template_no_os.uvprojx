# Keil uVision project template_no_os.uvprojx, settings and files
target template_no_os_AC6 (6230000::V6.23::ARMCLANG)
  device: STM32C542RCT6 STMicroelectronics
  pack: STMicroelectronics.stm32c5xx_dfp.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: template_no_os
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: STM32c542xx _RTE_ USE_EXTERNAL_ENV
  c include: ..\..\..\..\..\stm32c5xx_drivers\hal;..\..\..\..\..\stm32c5xx_drivers\ll;..\..\..\..\..\arch\cmsis\CMSIS\Core\Include;..\..\..\..\..\stm32c5xx_dfp\Include;..\generated\hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\user_modifiable\Device\STM32C542RCT6\stm32c542xc_flash.sct
  group application
    ../../application/: main.c
    ../user_modifiable/Device/STM32C542RCT6/: startup_stm32c542xx.c system_stm32c5xx.c
  group stm32c5xx_hal_drivers
    ../../../../../stm32c5xx_drivers/hal/: stm32c5xx_hal.c stm32c5xx_hal_cortex.c stm32c5xx_hal_exti.c stm32c5xx_hal_flash.c stm32c5xx_hal_flash_itf.c stm32c5xx_hal_gpio.c stm32c5xx_hal_icache.c stm32c5xx_hal_pwr.c stm32c5xx_hal_rcc.c
  group System
    ../generated/hal/: mx_cortex_nvic.c mx_icache.c mx_rcc.c mx_system.c mx_cortex_mpu.c
